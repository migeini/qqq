# Keil uVision project VirtualCOMPort.uvprojx, settings and files
target VirtualCOMPort (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: VirtualCOMPort +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\CMSIS\CM3;..\CMSIS\CM3\CORE;..\CMSIS\CM3\STARTUP;..\CMSIS\STM32LIB\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\USB\USBLIB\inc;..\USB\Mass_Storage\inc;..\HARDWARE;..\HARDWARE\LED;..\Com-Rule;..\HARDWARE\LCD;..\HARDWARE\AD985x;..\HARDWARE\KEY;..\Soft\Task;..\HARDWARE\TIMER;..\HARDWARE\ADC;..\SYSTEM\usart;..\HARDWARE\chuas
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group CMSIS
    ../CMSIS/CM3/CORE/: core_cm3.c
    ../CMSIS/CM3/: stm32f10x_it.c system_stm32f10x.c
    ../CMSIS/CM3/STARTUP/: startup_stm32f10x_hd.s
  group FWLIB
    ../CMSIS/STM32LIB/src/: misc.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group USER
    ./: main.c
    ../Soft/Task/: task_manage.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/AD985x/: AD985x.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/chuas/: cmd_queue.c hmi_driver.c
    ../../../修改/2.0/HARDWARE/chuas/: cmd_process.h cmd_queue.h hmi_driver.h
    ../chuan/: data_conversion.c data_conversion.h ping.c ping.h timer.h vol_collect.c vol_collect.h
